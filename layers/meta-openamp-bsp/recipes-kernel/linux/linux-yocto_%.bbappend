OAMPBSPPATHS := "${THISDIR}/${PN}:"

COMPATIBLE_MACHINE:generic-armv7a = "generic-armv7a"
FILESEXTRAPATHS:prepend:generic-armv7a = "${ARMFILESPATHS}"
